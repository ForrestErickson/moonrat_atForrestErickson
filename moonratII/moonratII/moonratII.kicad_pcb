# Repository ForrestErickson/moonrat_atForrestErickson

## KiCad design moonratII/moonratII/moonratII.kicad_pcb

Board: 2 copper layers, 108.0 x 65.0 mm, 36 parts (5 on the bottom side), 24 nets.

Parts:
A1: Arduino_UNO_R3; Arduino_UNO_R3_NoMountingHoles3D
BZ1: Buzzer_Adafruit_P1536A; Buzzer_12.2mm_9.7mm_7.62mm
D1: Schottky 2A; D_SMB
F1: Polyfuse 6A; Fuse_BSMD_1812
H1, H2, H3, H4, H5, H6: MountingHole_Pad_3.5mm; MountingHole_3.5mm_Pad_Via
J1: Barrel_Jack_Switch_SMT; BarrelJack_CLIFF_FC681465S_SMT_Horizontal
J2: HS96L03W2C03_0.96_Oled
J3: PinHeader_1x06_P2.54mm_Vertical
J4, J7: PinHeader_1x08_P2.54mm_Vertical
J5, J10: Conn_02x05_Odd_Even; IDC-Header_2x05_P2.54mm_Vertical
J6, J9: Screw_Terminal_01x06; TerminalBlock_TE_282834-6_1x06_P2.54mm_Horizontal
J8: PinHeader_1x10_P2.54mm_Vertical
J11: Screw_Terminal_01x02; TerminalBlock_TE_282834-2_1x02_P2.54mm_Horizontal
Q1: IRF520N; TO-220-3_Vertical
Q2: BSS138; SOT-23
R1, R7: 1R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2, R3, R4, R5, R6: 1K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1, SW2, SW3: 6mm 2 Pin Tact NO Breadboard Friendly; SW_PUSH_6mm
TP1, TP2: TP_GND; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded
U1: TMP36xS; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+5P: J9.4, J10.3, J10.8, R7.2, U1.8 (+Vs)
+5V: A1.5 (+5V), BZ1.1 (-), J2.2, J5.3, J5.8, J6.4
BTN_DOWN: A1.22 (D7), R5.2, SW1.1, SW1.2
BTN_SELECT: A1.20 (D5), R3.2, SW2.1, SW2.2
BTN_UP: A1.21 (D6), R4.2, SW3.1, SW3.2
BUZZER_ON: A1.24 (D9), R6.1
GND: A1.6 (GND), A1.7 (GND), A1.29 (GND), H1.1, H2.1, H3.1, H4.1, J1.2, J1.3, J2.1, J2.5, J2.6, J2.7, J2.8, J5.2, J5.9, J6.1, J6.6, Q1.3 (S), Q2.2 (S), R3.1, R4.1, R5.1, TP1.1
GND1: H5.1, H6.1, J9.1, J9.6, J10.2, J10.9, TP2.1, U1.4 (GND)
HEATER_ON: Q1.1 (G), R2.1
HeaterDrive: J5.1, J5.10, J6.3, Q1.2 (D)
HeaterDrive_IB: D1.1 (K), J9.3, J10.1, J10.10
unnamed: A1.23 (D8), R2.2
unnamed: BZ1.2 (+), Q2.3 (D)
unnamed: D1.2 (A), J11.2
unnamed: F1.2, J1.1, J1.4
unnamed: Q2.1 (G), R6.2
unnamed: R7.1, U1.5 (~SHUTDOWN)
SCL: A1.14 (SCL/A5), J2.3
SDA: A1.13 (SDA/A4), J2.4
TEMP_IN: A1.9 (A0), R1.1
TempOut: J5.4, J5.7, J6.5, R1.2
TempOut_IB: J9.5, J10.4, J10.7, U1.1 (Vout)
VCC: A1.8 (VIN), F1.1, J5.5, J5.6, J6.2
VCCQ: J9.2, J10.5, J10.6, J11.1

## Commit log

2023-10-28 Add routing to the heater side.
